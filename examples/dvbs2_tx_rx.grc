options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_tx_rx
    output_language: python
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1.0/(10**(float(snr)/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded.ts
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ../data/example.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: Simulate frequency offset
    phase_inc: '-2 * pi * (freq_offset / samp_rate)'
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    comment: Frequency Correction Block
    phase_inc: '0'
    tag_inc_update: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debug Level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.0045'
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(nfilts, samp_rate*nfilts, sym_rate, rolloff, taps*nfilts)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    rolloff: RO_0_20
    standard: DVB-S2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: constellation
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: constellation
    framesize: frame_size
    rate: code_rate
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: constellation
    framesize: frame_size
    interpolation: INTERPOLATION_OFF
    rate: code_rate
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: constellation
    framesize: frame_size
    goldcode: '0'
    pilots: PILOTS_ON
    rate: code_rate
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    constellation: constellation
    framesize: frame_size
    infomode: INFO_OFF
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_plsync_cc_0
  id: dvbs2rx_plsync_cc
  parameters:
    debug_level: debug
    freq_est_period: '20'
    gold_code: '0'
    sps: '2.0'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, sym_rate, rolloff, taps)
    type: ccc
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: Simulated carrier frequency offset in Hz
    type: eng_float
    value: '50'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK2/3
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@3
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@0
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tabs@1
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@2
    size: plframe_len - pilot_len - plheader_len
    srate: sym_rate
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: SNR (dB)
    type: intx
    value: '10'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: Symbol rate
    short_id: s
    type: intx
    value: '1000000'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Overview
    label1: Symbol Timing
    label2: Frame Timing
    label3: Phase Recovery
    num_tabs: '4'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: phy-channel-in
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: phy-channel-out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: phy-channel-out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: phy-channel-in
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_rotator_cc_0_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_1_0_0, '0']
- [blocks_file_source_0_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_add_xx_0, '0']
- [blocks_rotator_cc_0_0_0, '0', digital_symbol_sync_xx_1, '0']
- [blocks_rotator_cc_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1_0, '0']
- [digital_symbol_sync_xx_1, '0', dvbs2rx_plsync_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_1, '1', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_1, '2', qtgui_time_sink_x_0, '1']
- [digital_symbol_sync_xx_1, '3', qtgui_time_sink_x_0, '2']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', dtv_dvbs2_physical_cc_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', fft_filter_xxx_0, '0']
- [dvbs2rx_bbdeheader_bb_0, '0', blocks_file_sink_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_plsync_cc_0, '0', dvbs2rx_ldpc_decoder_cb_0, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_const_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_time_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, rotator_phase_inc, blocks_rotator_cc_0_0_0, cmd]
- [fft_filter_xxx_0, '0', blocks_throttle_0, '0']
- [virtual_source_1_0, '0', analog_agc_xx_0, '0']
- [virtual_source_1_0_0, '0', blocks_rotator_cc_0_0, '0']

metadata:
  file_format: 1
