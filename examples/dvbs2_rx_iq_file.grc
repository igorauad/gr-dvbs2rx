options:
  parameters:
    generate_options: qt_gui
    id: dvbs2_rx_iq_file
    output_language: python
  states: {}

blocks:
- name: max_n_slots
  id: variable
  parameters:
    value: int((360-1)/16)
  states: {}
- name: max_plframe_len_syms
  id: variable
  parameters:
    value: (360 + 1)*90 + max_n_slots*36
  states: {}
- name: rolloff_table
  id: variable
  parameters:
    value: '[0.35, 0.25, 0.2]'
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: float(rolloff_table[rolloff])
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: rrc_rolloff
    gain: rrc_nfilts
    ntaps: rrc_delay*sps*rrc_nfilts
    samp_rate: samp_rate*rrc_nfilts
    sym_rate: sym_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127'
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filename
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.008'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.008'
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
    tag_inc_update: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dvbs2rx_plsync_cc_0
  id: dvbs2rx_plsync_cc
  parameters:
    debug_level: debug
    freq_est_period: '20'
    gold_code: '0'
    sps: '2.0'
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debug Level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    nfilters: rrc_nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: rrc_nfilts
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: filename
  id: parameter
  parameters:
    label: IQ FIle
    short_id: f
    type: str
    value: data/qpsk_1_4.iq
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@3
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tabs@1
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@2
    size: max_plframe_len_syms
    srate: sym_rate
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Roll-off factor (0 for 0.35, 1 for 0.25 and 2 for 0.2)
    short_id: r
    type: intx
    value: '2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: Root-raised cosine (RRC) filter delay
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: Number of branches in the polyphase implementation of the RRC filter
    type: intx
    value: '32'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Overview
    label1: Symbol Timing
    label2: Frame Timing
    label3: Phase Recovery
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq_stream
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_uchar_to_float_0_0, '0']
- [blocks_file_source_0, '0', blocks_deinterleave_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_rotator_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_const_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_time_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, rotator_phase_inc, blocks_rotator_cc_0, phase_inc]
- [digital_symbol_sync_xx_0, '0', dvbs2rx_plsync_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_0, '1']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_0, '2']
- [virtual_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
