options:
  parameters:
    generate_options: qt_gui
    id: dvbs2_plheader_sync
    output_language: python
  states: {}

blocks:
- name: freq_offset
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '4140'
  states: {}
- name: plheader
  id: variable
  parameters:
    value: ((+0.7071 +0.7071j), (+0.7071 -0.7071j), (-0.7071 -0.7071j), (-0.7071 +0.7071j), (+0.7071 +0.7071j), (-0.7071 +0.7071j), (-0.7071 -0.7071j), (+0.7071 -0.7071j), (+0.7071 +0.7071j), (+0.7071 -0.7071j), (+0.7071 +0.7071j), (-0.7071 +0.7071j), (-0.7071 -0.7071j), (-0.7071 +0.7071j), (-0.7071 -0.7071j), (+0.7071 -0.7071j), (-0.7071 -0.7071j), (-0.7071 +0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (+0.7071 +0.7071j),(-0.7071 +0.7071j), (+0.7071 +0.7071j), (-0.7071 +0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (-0.7071 -0.7071j),(-0.7071 +0.7071j), (-0.7071 -0.7071j), (+0.7071 -0.7071j),(-0.7071 -0.7071j), (+0.7071 -0.7071j), (+0.7071 +0.7071j),(+0.7071 -0.7071j), (-0.7071 -0.7071j), (-0.7071 +0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (-0.7071 -0.7071j),(+0.7071 -0.7071j), (-0.7071 -0.7071j), (-0.7071 +0.7071j),(+0.7071 +0.7071j), (+0.7071 -0.7071j), (+0.7071 +0.7071j),(-0.7071 +0.7071j), (-0.7071 -0.7071j), (+0.7071 -0.7071j),(-0.7071 -0.7071j), (+0.7071 -0.7071j), (-0.7071 -0.7071j),(+0.7071 -0.7071j), (-0.7071 -0.7071j), (+0.7071 -0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (-0.7071 -0.7071j),(-0.7071 +0.7071j), (+0.7071 +0.7071j), (+0.7071 -0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (+0.7071 +0.7071j),(-0.7071 +0.7071j), (+0.7071 +0.7071j), (-0.7071 +0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (+0.7071 +0.7071j),(-0.7071 +0.7071j), (-0.7071 -0.7071j), (+0.7071 -0.7071j),(-0.7071 -0.7071j), (-0.7071 +0.7071j), (+0.7071 +0.7071j),(-0.7071 +0.7071j), (+0.7071 +0.7071j), (+0.7071 -0.7071j),(-0.7071 -0.7071j), (+0.7071 -0.7071j), (-0.7071 -0.7071j),(-0.7071 +0.7071j), (+0.7071 +0.7071j), (-0.7071 +0.7071j),(-0.7071 -0.7071j), (+0.7071 -0.7071j), (+0.7071 +0.7071j), (+0.7071 -0.7071j), (-0.7071 -0.7071j), (-0.7071 +0.7071j))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*sym_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: Simulate Rx frequency offset
    phase_inc: '-2*pi*freq_offset'
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: Frequency Correction Block
    phase_inc: '0'
    tag_inc_update: 'True'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[len(plheader), plframe_len - len(plheader)]'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: plheader
  states: {}
- name: dvbs2rx_plsync_cc_0
  id: dvbs2rx_plsync_cc
  parameters:
    debug_level: debug
    freq_est_period: '10'
    gold_code: '0'
    sps: sps
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debug Level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@0
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@1
    size: plframe_len - len(plheader)
    srate: sym_rate
    type: complex
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Constellation
    label1: Output Symbols
    num_tabs: '2'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_stream_mux_0, '1']
- [blocks_rotator_cc_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_rotator_cc_0_0, '0', dvbs2rx_plsync_cc_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_const_sink_x_0, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_time_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, rotator_phase_inc, blocks_rotator_cc_0_0, phase_inc]

metadata:
  file_format: 1
