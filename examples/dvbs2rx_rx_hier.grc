options:
  parameters:
    category: '[Core]/Digital Television/DVB-S2'
    description: DVB-S2 Rx
    generate_options: hb
    id: dvbs2rx_rx_hier
    output_language: python
    title: DVB-S2 Rx Hierarchical Block
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: params
  id: dvbs2rx_dvb_params
  parameters:
    code_rate: code_rate
    constellation: constellation
    frame_size: frame_size
    pilots: 'True'
    rolloff: rolloff
    standard: DVB-S2
    vl_snr: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC reference
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: agc_gain
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debugging Level
    type: intx
    value: '0'
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: debug
    framesize: params.framesize
    rate: params.rate
    standard: params.standard
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: params.framesize
    rate: params.rate
    standard: params.standard
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: debug
    framesize: params.framesize
    outputmode: OM_MESSAGE
    rate: params.rate
    standard: params.standard
  states: {}
- name: dvbs2rx_ldpc_decoder_bb_0
  id: dvbs2rx_ldpc_decoder_bb
  parameters:
    constellation: params.constellation
    debug_level: debug
    framesize: params.framesize
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: params.rate
    standard: params.standard
  states: {}
- name: dvbs2rx_plsync_cc_0
  id: dvbs2rx_plsync_cc
  parameters:
    acm_vcm: 'True'
    debug_level: debug
    freq_est_period: pl_freq_est_period
    gold_code: gold_code
    multistream: 'True'
    pls_filter_hi: '0xFFFFFFFFFFFFFFFF'
    pls_filter_lo: '0xFFFFFFFFFFFFFFFF'
    sps: sps
  states: {}
- name: dvbs2rx_rotator_cc_0
  id: dvbs2rx_rotator_cc
  parameters:
    comment: Frequency Correction Block
    phase_inc: '0'
    tag_inc_update: 'True'
  states: {}
- name: dvbs2rx_symbol_sync_cc_0
  id: dvbs2rx_symbol_sync_cc
  parameters:
    damping_factor: sym_sync_damping
    interp_method: INTERP_POLYPHASE
    loop_bw: sym_sync_loop_bw
    n_subfilt: rrc_nfilts
    rolloff: rolloff
    rrc_delay: rrc_delay
    sps: sps
  states: {}
- name: dvbs2rx_xfecframe_demapper_cb_0
  id: dvbs2rx_xfecframe_demapper_cb
  parameters:
    constellation: params.constellation
    framesize: params.framesize
    rate: params.rate
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    type: str
    value: normal
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    type: str
    value: QPSK1/4
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: sym_sync_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: pl_sync_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: rotator_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: agc_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL Freq. Corr. Period
    type: intx
    value: '20'
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Rolloff factor
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: Polyphase RRC branches
    type: intx
    value: '128'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Oversampling ratio
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: Symbol rate
    type: intx
    value: '1000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: Symbol Sync Damping Factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: Symbol Sync Loop BW
    type: eng_float
    value: '0.0045'
  states: {}

connections:
- [analog_agc_xx_0, '0', dvbs2rx_rotator_cc_0, '0']
- [analog_agc_xx_0, '0', pad_sink_2_0, '0']
- [dvbs2rx_bbdeheader_bb_0, '0', pad_sink_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, llr_pdu, dvbs2rx_xfecframe_demapper_cb_0, llr_pdu]
- [dvbs2rx_plsync_cc_0, '0', dvbs2rx_xfecframe_demapper_cb_0, '0']
- [dvbs2rx_plsync_cc_0, '0', pad_sink_1_0, '0']
- [dvbs2rx_plsync_cc_0, rotator_phase_inc, dvbs2rx_rotator_cc_0, cmd]
- [dvbs2rx_rotator_cc_0, '0', dvbs2rx_symbol_sync_cc_0, '0']
- [dvbs2rx_rotator_cc_0, '0', pad_sink_2, '0']
- [dvbs2rx_symbol_sync_cc_0, '0', dvbs2rx_plsync_cc_0, '0']
- [dvbs2rx_symbol_sync_cc_0, '0', pad_sink_1, '0']
- [dvbs2rx_xfecframe_demapper_cb_0, '0', dvbs2rx_ldpc_decoder_bb_0, '0']
- [pad_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
